# Keil uVision project emmc_bm_rpmb.uvprojx, settings and files
target emmc_bm_rpmb (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: emmc_bm_rpmb
  AfterMake: fromelf --bin --output bin\emmc_bm_rpmb.bin bin\emmc_bm_rpmb.axf
  AfterMake: fromelf -cedrst --output bin\emmc_bm_rpmb.txt bin\emmc_bm_rpmb.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4P AM_PACKAGE_BGA keil6
  c include: ../../../../../../mcu/apollo4p/hal/mcu;../src;../../../../../../third_party/crypto/mbedtls/include;../../../../../../mcu/apollo4p/hal;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../../../../../..;../../../../../../third_party/crypto/mbedtls/include/mbedtls;../../../../../../third_party/crypto/host/include;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../third_party/crypto/shared/include/pal/no_os;../../../../../../third_party/crypto/shared/include/pal;../../../../bsp;../../../../../../mcu/apollo4p
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c emmc_bm_rpmb.c
  group utils
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c am_util_syscalls.c
  group devices
    ../../../../../../devices/: am_devices_emmc_rpmb.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../third_party/crypto/host/lib/: libpal_no_os.lib libcc_312.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../third_party/crypto/mbedtls/library/: cryptombedtls.lib
