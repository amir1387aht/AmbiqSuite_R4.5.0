# IAR project coremark_pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; MITH_MEMORY_ONLY_VERSION=1; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; EZXML_NOMMAP=1; AM_FREERTOS; RUN_IN_SINGLE_TASK=1; REPORT_THMALLOC_STATS=0; DEBUG_ACCURATE_BITS=0; HEAP_IN_SSRAM_AND_PSRAM; AM_PART_APOLLO4P; USE_PRESET=1; USE_CRC_TABLE=1; THDEBUG=0; BMDEBUG=0; SELECT_PRESET_ID=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src\benchmarks\fp\linpack; ..\src\benchmarks\core; ..\src\benchmarks\consumer_v2\cjpeg\data; ..\src\benchmarks\darkmark\zip\zlib-1.2.8; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\src\benchmarks\fp\loops; ..\src\benchmarks\libbmp; ..\src\FreeRTOS_Plus_POSIX\FreeRTOS-Plus-POSIX\include; ..\src\FreeRTOS_Plus_POSIX\include\FreeRTOS_POSIX; ..\src\benchmarks\consumer_v2\cjpeg; ..\..\..\..\..\..; ..\src\mith\include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\src\FreeRTOS_Plus_POSIX\include\private; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\utils; ..\src\benchmarks\fp\fft_radix2; ..\src\benchmarks\fp\nnet; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\src; ..\..\..\..\bsp; ..\src\benchmarks\darkmark\sha; ..\src\mith\al\include; ..\src\benchmarks\darkmark\parser; ..\src\benchmarks\libjpeg; ..\src\FreeRTOS_Plus_POSIX\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: coremark_pro.bin
  ILINK.IlinkOutputFile: coremark_pro.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; MITH_MEMORY_ONLY_VERSION=1; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; EZXML_NOMMAP=1; AM_FREERTOS; RUN_IN_SINGLE_TASK=1; REPORT_THMALLOC_STATS=0; DEBUG_ACCURATE_BITS=0; HEAP_IN_SSRAM_AND_PSRAM; AM_PART_APOLLO4P; USE_PRESET=1; USE_CRC_TABLE=1; THDEBUG=0; BMDEBUG=0; SELECT_PRESET_ID=1
  group (top)
    ../src/workloads/core/: core.c
    ../src/workloads/linear_alg-mid-100x100-sp/: linear_alg-mid-100x100-sp.c
    ../src/workloads/nnet_test/: nnet_test.c
    ../src/workloads/parser-125k/: parser-125k.c
    ../src/workloads/zip-test/: zip-test.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../src/mith/src/: md5.c mith_lib.c mith_workload.c th_bignum.c th_encode.c th_getopt.c th_lib.c th_math.c th_rand.c
    ../src/workloads/loops-all-mid-10k-sp/: loops-all-mid-10k-sp.c
    ../src/FreeRTOS_Plus_POSIX/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
    ../src/: am_resources.c coremark_pro.c heap_4_external.c heap_5_external.c psram.c rtos.c
    ../src/mith/al/src/: al_file.c al_single.c al_smp.c th_al.c
    ../src/workloads/sha-test/: sha-test.c
    ../src/workloads/radix2-big-64k/: radix2-big-64k.c
    ../src/workloads/cjpeg-rose7-preset/: cjpeg-rose7-preset.c
    ../src/benchmarks/fp/linpack/: linpack.c
    ../src/benchmarks/core/: core_list_join.c core_matrix.c core_mith.c core_portme.c core_state.c core_util.c
    ../src/benchmarks/consumer_v2/cjpeg/data/: goose_bmp.c Rose256_bmp.c
    ../src/benchmarks/darkmark/zip/zlib-1.2.8/: adler32.c compress.c crc32.c deflate.c gzclose.c gzlib.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
    ../src/benchmarks/fp/loops/: loops.c
    ../src/benchmarks/fp/nnet/ref-sp/: 1letter.c letters.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../src/benchmarks/consumer_v2/cjpeg/: bmark_lite.c bm_lib.c cdjpeg.c cjpeg.c filedata.c jcapimin.c jcapistd.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jdatadst.c jerror.c jfdctint.c jmemansi.c jmemmgr.c jutils.c rdbmp.c
    ../src/benchmarks/fp/fft_radix2/ref-sp/: 2K.c 32K.c 4K.c data3_big.c data4_mid.c data5_small.c
    ../src/benchmarks/fp/loops/ref-sp/: 100.c 100k.c 100kdot.c 10k.c 10kdot.c 1k.c 1kdot.c 32.c
    ../src/benchmarks/fp/linpack/ref/: inputs_f32.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c am_util_syscalls.c
    ../src/benchmarks/fp/nnet/: nnet.c
    ../src/benchmarks/fp/fft_radix2/: fft_radix2.c
    ../src/benchmarks/darkmark/sha/: sha256.c shabench.c
    ../src/benchmarks/darkmark/parser/: ezxml.c parser.c
    ../src/benchmarks/darkmark/zip/: zip_darkmark.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ./: startup_iar.c
