# Keil uVision project nemagfx_blend.uvprojx, settings and files
target nemagfx_blend (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_blend
  AfterMake: fromelf --bin --output bin\nemagfx_blend.bin bin\nemagfx_blend.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_blend.txt bin\nemagfx_blend.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NEMA_PLATFORM=apollo4p_nemagfx NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK BAREMETAL LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_PART_APOLLO4P AM_PACKAGE_BGA keil6
  c include: ../../../../../../mcu/apollo4p;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../src;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../..;../../../../bsp;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../mcu/apollo4p/hal;../../../../../../mcu/apollo4p/hal/mcu;../../../../../../utils;../../../../../../devices;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c nemagfx_blend.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
