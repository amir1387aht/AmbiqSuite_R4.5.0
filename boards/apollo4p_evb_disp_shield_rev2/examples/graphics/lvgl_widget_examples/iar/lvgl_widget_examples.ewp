# IAR project lvgl_widget_examples.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; LV_AMBIQ_FB_RESY=454; LV_AMBIQ_FB_REFRESH_TWO; apollo4p_evb_disp_shield_rev2; LV_CONF_INCLUDE_SIMPLE; NEMA_CUSTOM_MALLOC_INCLUDE="lv_ambiq_nema_hal.h"; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_PACKAGE_BGA; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_FREERTOS; LV_AMBIQ_FB_RESX=454; LV_AMBIQ_FB_USE_RGB888=0; WAIT_IRQ_BINARY_SEMAPHORE=1; AM_PART_APOLLO4P; LV_AMBIQ_FB_USE_RGB565=1; NEMA_PLATFORM=apollo4p_nemagfx; LV_LVGL_H_INCLUDE_SIMPLE; NEMA_USE_CUSTOM_MALLOC; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\FatFs\source; ..\..\..\..\..\..\third_party\LVGL\lvgl\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\LVGL\ambiq_support; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaVG; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\LVGL\lvgl\src\gpu; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\src; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lvgl_widget_examples.bin
  ILINK.IlinkOutputFile: lvgl_widget_examples.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4p_nemagfx\iar\bin\lib_nema_apollo4p_nemagfx.a; ..\..\..\..\..\..\third_party\LVGL\ambiq_support\gpu_lib_apollo4\iar\bin\lvgl_ambiq_porting.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; LV_AMBIQ_FB_RESY=454; LV_AMBIQ_FB_REFRESH_TWO; apollo4p_evb_disp_shield_rev2; LV_CONF_INCLUDE_SIMPLE; NEMA_CUSTOM_MALLOC_INCLUDE="lv_ambiq_nema_hal.h"; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_PACKAGE_BGA; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_FREERTOS; LV_AMBIQ_FB_RESX=454; LV_AMBIQ_FB_USE_RGB888=0; WAIT_IRQ_BINARY_SEMAPHORE=1; AM_PART_APOLLO4P; LV_AMBIQ_FB_USE_RGB565=1; NEMA_PLATFORM=apollo4p_nemagfx; LV_LVGL_H_INCLUDE_SIMPLE; NEMA_USE_CUSTOM_MALLOC; AM_UTIL_FAULTISR_PRINT
  group (top)
    ../../../../../../third_party/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/png/: lodepng.c lv_png.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../../../../third_party/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/win/: lv_win.c
    ../../../../../../third_party/LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/img/: lv_img.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../third_party/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/bmp/: lv_bmp.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../src/: am_resources.c gui_task.c lvgl_widget_examples.c rtos.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/animimg/: lv_animimg.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/btn/: lv_btn.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../../../../third_party/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../../../../third_party/FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ../../../../../../third_party/LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../../../../../../third_party/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../../../../third_party/LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/freetype/: lv_freetype.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/meter/: lv_meter.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../../../../../../third_party/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../../../../../../third_party/LVGL/lvgl/src/themes/basic/: lv_theme_basic.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../../../../third_party/LVGL/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../../../../third_party/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../../../third_party/LVGL/lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ../../../../../../third_party/LVGL/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../../../../devices/: am_devices_display_generic.c am_devices_tma525.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/LVGL/lvgl/src/gpu/: lv_gpu_ambiq_nema.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/LVGL/ambiq_support/: display_task_cpu_only.c display_task_fake.c display_task_one_and_partial_fb.c display_task_one_fb.c display_task_two_fb.c lv_ambiq_decoder.c lv_ambiq_font_align.c lv_ambiq_fs.c lv_ambiq_misc.c lv_ambiq_nema_hal.c lv_ambiq_touch.c mmc_apollo4.c
    ./: startup_iar.c
