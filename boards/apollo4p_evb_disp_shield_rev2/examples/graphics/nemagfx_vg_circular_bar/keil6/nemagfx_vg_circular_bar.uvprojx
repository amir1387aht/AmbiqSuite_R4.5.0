# Keil uVision project nemagfx_vg_circular_bar.uvprojx, settings and files
target nemagfx_vg_circular_bar (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_vg_circular_bar
  AfterMake: fromelf --bin --output bin\nemagfx_vg_circular_bar.bin bin\nemagfx_vg_circular_bar.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_vg_circular_bar.txt bin\nemagfx_vg_circular_bar.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA RUN_IN_HP_MODE VMEM_BASEADDR=0x10060400 AM_FREERTOS VMEM_SIZE=0x180000 AM_UTIL_FAULTISR_PRINT LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK apollo4p_evb_disp_shield_rev2 AM_PART_APOLLO4P NEMA_PLATFORM=apollo4p_nemagfx keil6
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4p;../../../../bsp;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../devices;../src;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c display_task.c graphics_power_control.c gui_task.c nemagfx_vg_circular_bar.c psram.c render_task.c rtos.c
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4/: port.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group resource
    ../src/resource/: DejaVuSans_ttf_kern.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c am_devices_dc_xspi_raydium.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
