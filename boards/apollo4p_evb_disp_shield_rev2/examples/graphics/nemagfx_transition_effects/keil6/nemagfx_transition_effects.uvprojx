# Keil uVision project nemagfx_transition_effects.uvprojx, settings and files
target nemagfx_transition_effects (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_transition_effects
  AfterMake: fromelf --bin --output bin\nemagfx_transition_effects.bin bin\nemagfx_transition_effects.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_transition_effects.txt bin\nemagfx_transition_effects.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK BAREMETAL AM_FREERTOS NEMA_PLATFORM=apollo4p_nemagfx LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_PACKAGE_BGA AM_PART_APOLLO4P keil6
  c include: ../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../mcu/apollo4p;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx;../src;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaVG;../../../../../../devices;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../utils;../../../../../../mcu/apollo4p/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../mcu/apollo4p/hal/mcu;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4/: port.c
  group src
    ../src/: am_resources.c gui_task.c nemagfx_transition_effects.c rtos.c
  group ThinkSi_apollo4p_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group devices
    ../../../../../../devices/: am_devices_display_generic.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../third_party/ThinkSi/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
