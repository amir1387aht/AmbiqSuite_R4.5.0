# IAR project mspi_hex_ddr_aps25616n_psram_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; APS25616N; AM_PART_APOLLO4P; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\devices; ..\src; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\utils; ..\..\..\..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mspi_hex_ddr_aps25616n_psram_example.bin
  ILINK.IlinkOutputFile: mspi_hex_ddr_aps25616n_psram_example.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; APS25616N; AM_PART_APOLLO4P; AM_UTIL_FAULTISR_PRINT
  group (top)
    ../src/: am_resources.c mspi_hex_ddr_aps25616n_psram_example.c
    ../../../../../../devices/: am_devices_mspi_psram_aps25616n.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
