# Keil uVision project mspi_ddr_octal_psram_example.uvprojx, settings and files
target mspi_ddr_octal_psram_example (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_ddr_octal_psram_example
  AfterMake: fromelf --bin --output bin\mspi_ddr_octal_psram_example.bin bin\mspi_ddr_octal_psram_example.axf
  AfterMake: fromelf -cedrst --output bin\mspi_ddr_octal_psram_example.txt bin\mspi_ddr_octal_psram_example.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA AM_PART_APOLLO4P APS12808L keil6
  c include: ../../../../../../devices;../../../../../../CMSIS/ARM/Include;../../../../../../utils;../../../../../..;../../../../bsp;../../../../../../mcu/apollo4p;../src;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c mspi_ddr_octal_psram_example.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_mspi_psram_aps12808l.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
