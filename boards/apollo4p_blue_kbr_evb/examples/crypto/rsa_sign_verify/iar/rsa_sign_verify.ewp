# IAR project rsa_sign_verify.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; CC_IOT; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO4P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\third_party\crypto\host\include; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os; ..\..\..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rsa_sign_verify.bin
  ILINK.IlinkOutputFile: rsa_sign_verify.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; CC_IOT; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO4P
  group (top)
    ../src/: am_resources.c rsa_sign_verify.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_syscalls.c
    ./: startup_iar.c
