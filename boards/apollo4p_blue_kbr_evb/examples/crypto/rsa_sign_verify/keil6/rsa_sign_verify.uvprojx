# Keil uVision project rsa_sign_verify.uvprojx, settings and files
target rsa_sign_verify (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: rsa_sign_verify
  AfterMake: fromelf --bin --output bin\rsa_sign_verify.bin bin\rsa_sign_verify.axf
  AfterMake: fromelf -cedrst --output bin\rsa_sign_verify.txt bin\rsa_sign_verify.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA CC_IOT AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO4P keil6
  c include: ../../../../../../third_party/crypto/shared/include/pal;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../CMSIS/ARM/Include;../src;../../../../../../devices;../../../../../../utils;../../../../../../mcu/apollo4p;../../../../bsp;../../../../../../third_party/crypto/mbedtls/include;../../../../../../third_party/crypto/host/include;../../../../../../third_party/crypto/shared/include/pal/no_os;../../../../../..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c rsa_sign_verify.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_syscalls.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../third_party/crypto/host/lib/: libcc_312.lib libpal_no_os.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../third_party/crypto/mbedtls/library/: cryptombedtls.lib
