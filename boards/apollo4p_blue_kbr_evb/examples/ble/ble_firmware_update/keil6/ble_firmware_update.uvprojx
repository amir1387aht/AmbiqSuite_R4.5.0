# Keil uVision project ble_firmware_update.uvprojx, settings and files
target ble_firmware_update (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ble_firmware_update
  AfterMake: fromelf --bin --output bin\ble_firmware_update.bin bin\ble_firmware_update.axf
  AfterMake: fromelf -cedrst --output bin\ble_firmware_update.txt bin\ble_firmware_update.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4P keil6
  c include: ../../../../../..;../../../../../../mcu/apollo4p/hal;../../../../../../mcu/apollo4p;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/cooper;../../../../bsp;../../../../../../utils;../../../../../../devices;../../../../../../mcu/apollo4p/hal/mcu;../src;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c ble_firmware_update.c
  group devices
    ../../../../../../devices/: am_devices_cooper.c
  group utils
    ../../../../../../utils/: am_util_ble_cooper.c am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
