# Keil uVision project i2s_loopback.uvprojx, settings and files
target i2s_loopback (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: i2s_loopback
  AfterMake: fromelf --bin --output bin\i2s_loopback.bin bin\i2s_loopback.axf
  AfterMake: fromelf -cedrst --output bin\i2s_loopback.txt bin\i2s_loopback.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4P UNITY_INCLUDE_CONFIG_H AM_UTIL_FAULTISR_PRINT __FPU_PRESENT keil6
  c include: ../../../../../../devices;../../../../bsp;../src;../../../../../../CMSIS/ARM/Include;../../../../../..;../../../../../../utils;../../../../../../mcu/apollo4p;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c i2s_loopback.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
