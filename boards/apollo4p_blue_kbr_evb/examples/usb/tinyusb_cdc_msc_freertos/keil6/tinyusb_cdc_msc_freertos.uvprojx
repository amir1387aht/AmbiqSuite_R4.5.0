# Keil uVision project tinyusb_cdc_msc_freertos.uvprojx, settings and files
target tinyusb_cdc_msc_freertos (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc_msc_freertos
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_msc_freertos.bin bin\tinyusb_cdc_msc_freertos.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc_msc_freertos.txt bin\tinyusb_cdc_msc_freertos.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED apollo4p_blue_kbr_evb CFG_TUSB_MCU=OPT_MCU_APOLLO4 AM_PACKAGE_BGA AM_FREERTOS AM_PART_APOLLO4P CFG_TUSB_DEBUG=0 keil6
  c include: ../../../../../../third_party/tinyusb/source/src/osal;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/tinyusb/source/src/class/msc;../../../../../../mcu/apollo4p/hal;../../../../bsp;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../../third_party/tinyusb/ambiq_port/apollo4;../../../../../../utils;../../../../../../third_party/tinyusb/source/src;../src;../../../../../..;../../../../../../third_party/tinyusb/source/src/common;../../../../../../mcu/apollo4p;../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../devices
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group FreeRTOSv10.5.1_AMapollo4
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4/: port.c
  group src
    ../src/: am_resources.c apollo4_board.c freertos_hook.c msc_disk.c rtos.c tinyusb_cdc_msc_freertos.c usb_descriptors.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group FreeRTOSv10.5.1_Source
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group tinyusb_msc
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
