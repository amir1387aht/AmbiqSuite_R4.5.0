# Keil uVision project tinyusb_cdc_disconnect.uvprojx, settings and files
target tinyusb_cdc_disconnect (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc_disconnect
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_disconnect.bin bin\tinyusb_cdc_disconnect.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc_disconnect.txt bin\tinyusb_cdc_disconnect.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED CFG_TUSB_MCU=OPT_MCU_APOLLO4 CFG_TUSB_DEBUG=0 AM_PART_APOLLO4P apollo4p_blue_kbr_evb keil6
  c include: ../../../../../../third_party/tinyusb/ambiq_port/apollo4;../../../../../../mcu/apollo4p/hal;../../../../bsp;../../../../../../utils;../../../../../../mcu/apollo4p;../../../../../../third_party/tinyusb/source/src/osal;../../../../../../devices;../../../../../../third_party/tinyusb/source/src/common;../src;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../third_party/tinyusb/source/src;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc_disconnect.c usb_descriptors.c usb_disconnect.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group devices
    ../../../../../../devices/: am_devices_button.c am_devices_led.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
