# IAR project tinyusb_cdc_hfrc2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; CFG_TUSB_DEBUG=2; AM_PART_APOLLO4P; CFG_TUSB_MCU=OPT_MCU_APOLLO4; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; apollo4p_blue_kbr_evb; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\tinyusb\source\src; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\src; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\bsp; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\..\..\third_party\tinyusb\ambiq_port\apollo4; ..\..\..\..\..\..\mcu\apollo4p
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_hfrc2.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_hfrc2.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; CFG_TUSB_DEBUG=2; AM_PART_APOLLO4P; CFG_TUSB_MCU=OPT_MCU_APOLLO4; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_HIGH_SPEED; apollo4p_blue_kbr_evb; AM_PACKAGE_BGA
  group (top)
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../src/: am_resources.c apollo4_board.c hfrc2_test_utils.c tinyusb_cdc_hfrc2.c usb_descriptors.c usb_timer_utils.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ./: startup_iar.c
