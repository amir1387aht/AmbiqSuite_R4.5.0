# Keil uVision project pwr_mspi.uvprojx, settings and files
target pwr_mspi (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: pwr_mspi
  AfterMake: fromelf --bin --output bin\pwr_mspi.bin bin\pwr_mspi.axf
  AfterMake: fromelf -cedrst --output bin\pwr_mspi.txt bin\pwr_mspi.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4P AM_PACKAGE_BGA keil6
  c include: ../../../../../../CMSIS/AmbiqMicro/Include;../../../../bsp;../src;../../../../../../devices;../../../../../../utils;../../../../../../mcu/apollo4p;../../../../../..;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c pwr_control_utils.c pwr_gpio_utils.c pwr_mspi.c pwr_timer_utils.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
