# Keil uVision project tdm_loopback.uvprojx, settings and files
target tdm_loopback (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tdm_loopback
  AfterMake: fromelf --bin --output bin\tdm_loopback.bin bin\tdm_loopback.axf
  AfterMake: fromelf -cedrst --output bin\tdm_loopback.txt bin\tdm_loopback.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4L AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT __FPU_PRESENT UNITY_INCLUDE_CONFIG_H keil6
  c include: ../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../../mcu/apollo4l;../../../../../..;../../../../bsp;../../../../../../CMSIS/ARM/Include;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c tdm_loopback.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_syscalls.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
