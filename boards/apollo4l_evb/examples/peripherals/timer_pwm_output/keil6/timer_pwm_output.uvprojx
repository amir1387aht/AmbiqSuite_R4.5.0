# Keil uVision project timer_pwm_output.uvprojx, settings and files
target timer_pwm_output (ARM-ADS)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.4.0
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: timer_pwm_output
  AfterMake: fromelf --bin --output bin\timer_pwm_output.bin bin\timer_pwm_output.axf
  AfterMake: fromelf -cedrst --output bin\timer_pwm_output.txt bin\timer_pwm_output.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4L keil6
  c include: ../src;../../../../../../devices;../../../../../../mcu/apollo4l;../../../../../../utils;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c low_power_config.c timer_pwm_output.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/: libam_hal.lib
