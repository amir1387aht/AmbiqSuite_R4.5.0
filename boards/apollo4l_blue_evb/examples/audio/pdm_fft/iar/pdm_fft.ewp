# IAR project pdm_fft.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KL-KBR AmbiqMicro AMAP42KL-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; __FPU_PRESENT; AM_PART_APOLLO4L; AM_UTIL_FAULTISR_PRINT; AM_PACKAGE_BGA; UNITY_INCLUDE_CONFIG_H
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\ARM\Include; ..\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4l\hal; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\mcu\apollo4l; ..\..\..\..\bsp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pdm_fft.bin
  ILINK.IlinkOutputFile: pdm_fft.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4l\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; __FPU_PRESENT; AM_PART_APOLLO4L; AM_UTIL_FAULTISR_PRINT; AM_PACKAGE_BGA; UNITY_INCLUDE_CONFIG_H
  group (top)
    ../src/: am_resources.c pdm_fft.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
