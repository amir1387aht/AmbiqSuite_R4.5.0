# IAR project emmc_bm_rpmb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4B; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\crypto\host\include; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\crypto\mbedtls\include; ..\..\..\..\..\..\third_party\crypto\mbedtls\include\mbedtls; ..\..\..\..\bsp; ..\..\..\..\..\..\mcu\apollo4b
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: emmc_bm_rpmb.bin
  ILINK.IlinkOutputFile: emmc_bm_rpmb.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO4B; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c emmc_bm_rpmb.c
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c am_util_syscalls.c
    ../../../../../../devices/: am_devices_emmc_rpmb.c
    ./: startup_iar.c
