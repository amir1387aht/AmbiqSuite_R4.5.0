# Keil uVision project sd_card_bm_fatfs.uvprojx, settings and files
target sd_card_bm_fatfs (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: sd_card_bm_fatfs
  AfterMake: fromelf --bin --output bin\sd_card_bm_fatfs.bin bin\sd_card_bm_fatfs.axf
  AfterMake: fromelf -cedrst --output bin\sd_card_bm_fatfs.txt bin\sd_card_bm_fatfs.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4B keil6
  c include: ../src;../../../../../../devices;../../../../../../mcu/apollo4b;../../../../../..;../../../../../../CMSIS/ARM/Include;../../../../../../utils;../../../../../../mcu/apollo4b/hal;../../../../bsp;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/FatFs/source
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c mmc_apollo4.c sd_card_bm_fatfs.c
  group FatFs_source
    ../../../../../../third_party/FatFs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group utils
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
