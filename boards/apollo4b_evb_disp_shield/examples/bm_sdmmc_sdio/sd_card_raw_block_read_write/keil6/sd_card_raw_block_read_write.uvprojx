# Keil uVision project sd_card_raw_block_read_write.uvprojx, settings and files
target sd_card_raw_block_read_write (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: sd_card_raw_block_read_write
  AfterMake: fromelf --bin --output bin\sd_card_raw_block_read_write.bin bin\sd_card_raw_block_read_write.axf
  AfterMake: fromelf -cedrst --output bin\sd_card_raw_block_read_write.txt bin\sd_card_raw_block_read_write.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4B AM_DEBUG_PRINTF AM_PACKAGE_BGA keil6
  c include: ../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../..;../../../../../../mcu/apollo4b;../../../../../../mcu/apollo4b/hal;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../../../../bsp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c sd_card_raw_block_read_write.c
  group utils
    ../../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
