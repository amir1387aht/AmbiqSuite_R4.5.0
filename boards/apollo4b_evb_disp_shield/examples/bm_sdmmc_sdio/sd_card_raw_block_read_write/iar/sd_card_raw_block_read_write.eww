<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\sd_card_raw_block_read_write.ewp</path>
  </project>
  <batchBuild/>
</workspace>



