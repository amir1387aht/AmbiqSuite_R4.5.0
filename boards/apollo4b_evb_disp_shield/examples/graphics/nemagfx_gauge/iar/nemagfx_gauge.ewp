# IAR project nemagfx_gauge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; USE_TSI_MALLOC; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; AM_PACKAGE_BGA; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_NEMAGUI_LIB; ENABLE_TE; CALCULATE_FPS; AM_PART_APOLLO4B; NEMA_PLATFORM=apollo4b_nemagfx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\src\generated\NemaGUI\include; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\src\generated\assets\fonts; ..\src\generated; ..\src\generated\assets\images; ..\..\..\..\..\..; ..\src\generated\NemaGUI\include\gitems; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_gauge.bin
  ILINK.IlinkOutputFile: nemagfx_gauge.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\NemaGUI\config\apollo4b\iar\bin\NemaGUI.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; USE_TSI_MALLOC; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; AM_PACKAGE_BGA; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; USE_NEMAGUI_LIB; ENABLE_TE; CALCULATE_FPS; AM_PART_APOLLO4B; NEMA_PLATFORM=apollo4b_nemagfx
  group (top)
    ../src/: am_resources.c gui_task.c nemagfx_gauge.c nemagui_porting.c rtos.c
    ../src/generated/: custom_callbacks.c event_list.c fonts.c framebuffers.c gui_tree.c images.c main.c screen_groups.c
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../devices/: am_devices_display_generic.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ./: startup_iar.c
