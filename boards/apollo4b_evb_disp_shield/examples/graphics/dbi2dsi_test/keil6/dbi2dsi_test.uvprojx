# Keil uVision project dbi2dsi_test.uvprojx, settings and files
target dbi2dsi_test (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: dbi2dsi_test
  AfterMake: fromelf --bin --output bin\dbi2dsi_test.bin bin\dbi2dsi_test.axf
  AfterMake: fromelf -cedrst --output bin\dbi2dsi_test.txt bin\dbi2dsi_test.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NEMA_PLATFORM=apollo4b_nemagfx BAREMETAL AM_PART_APOLLO4B AM_PACKAGE_BGA LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK keil6
  c include: ../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../utils;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../mcu/apollo4b/hal;../../../../../..;../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4b/hal/mcu;../src;../../../../../../devices;../../../../../../mcu/apollo4b;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group src
    ../src/: am_resources.c dbi2dsi_test.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil6/bin/: lib_nema_apollo4b_nemagfx.lib
