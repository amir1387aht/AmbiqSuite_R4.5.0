<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\lvgl_cellular_menu.ewp</path>
  </project>
  <batchBuild/>
</workspace>



