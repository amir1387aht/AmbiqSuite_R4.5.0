# IAR project nemagfx_coverflow.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_FREERTOS; NEMA_PLATFORM=apollo4b_nemagfx; AM_PART_APOLLO4B; BAREMETAL; AM_PACKAGE_BGA; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\src\generated; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_coverflow.bin
  ILINK.IlinkOutputFile: nemagfx_coverflow.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_FREERTOS; NEMA_PLATFORM=apollo4b_nemagfx; AM_PART_APOLLO4B; BAREMETAL; AM_PACKAGE_BGA; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK
  group (top)
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/: am_resources.c gui_task.c nemagfx_coverflow.c rtos.c
    ../src/generated/: coverflow.c
    ../../../../../../devices/: am_devices_display_generic.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ./: startup_iar.c
