# IAR project nemadc_darkening_effect.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMA_PLATFORM=apollo4b_nemagfx; AM_PACKAGE_BGA; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; BAREMETAL; AM_PART_APOLLO4B
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemadc_darkening_effect.bin
  ILINK.IlinkOutputFile: nemadc_darkening_effect.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; NEMA_PLATFORM=apollo4b_nemagfx; AM_PACKAGE_BGA; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; BAREMETAL; AM_PART_APOLLO4B
  group (top)
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../src/: am_resources.c nemadc_darkening_effect.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../devices/: am_devices_dc_dsi_raydium.c
    ./: startup_iar.c
