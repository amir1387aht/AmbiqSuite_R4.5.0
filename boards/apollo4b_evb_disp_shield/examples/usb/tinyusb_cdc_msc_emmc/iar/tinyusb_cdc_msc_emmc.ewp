# IAR project tinyusb_cdc_msc_emmc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; CFG_TUSB_MCU=OPT_MCU_APOLLO4; CFG_TUSB_DEBUG=0; AM_PART_APOLLO4B; apollo4b_evb_disp_shield; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\tinyusb\source\src\class\msc; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\..\..\third_party\tinyusb\ambiq_port\apollo4; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\src; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\source\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_msc_emmc.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_msc_emmc.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; CFG_TUSB_MCU=OPT_MCU_APOLLO4; CFG_TUSB_DEBUG=0; AM_PART_APOLLO4B; apollo4b_evb_disp_shield; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; AM_PACKAGE_BGA
  group (top)
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
    ../src/: am_resources.c apollo4_board.c msc_emmc_disk.c tinyusb_cdc_msc_emmc.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ./: startup_iar.c
