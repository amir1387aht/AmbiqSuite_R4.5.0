# Keil uVision project audadc_rtt_stream.uvprojx, settings and files
target audadc_rtt_stream (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: audadc_rtt_stream
  AfterMake: fromelf --bin --output bin\audadc_rtt_stream.bin bin\audadc_rtt_stream.axf
  AfterMake: fromelf -cedrst --output bin\audadc_rtt_stream.txt bin\audadc_rtt_stream.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4P AM_UTIL_FAULTISR_PRINT SEGGER_RTT_SECTION=\"SHARED_RW\" AM_PACKAGE_BGA __FPU_PRESENT keil6
  c include: ../../../../../../mcu/apollo4p/hal;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT;../../../../../../utils;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../mcu/apollo4p;../src;../../../../bsp;../../../../../..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c audadc_rtt_stream.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_led.c
  group SEGGER_RTT
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
