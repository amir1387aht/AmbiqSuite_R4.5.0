# IAR project while.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P; AM_PRINTF_BUFSIZE=256
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\src; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: while.bin
  ILINK.IlinkOutputFile: while.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO4P; AM_PRINTF_BUFSIZE=256
  group (top)
    ../src/: am_resources.c while.c
    ../../../../../../utils/: am_util_stdio.c
    ./: startup_iar.c
