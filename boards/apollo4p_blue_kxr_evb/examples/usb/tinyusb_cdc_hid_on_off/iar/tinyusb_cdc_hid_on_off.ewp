# IAR project tinyusb_cdc_hid_on_off.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; apollo4p_blue_kxr_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; CFG_TUSB_DEBUG=0; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; AM_PART_APOLLO4P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\tinyusb\ambiq_port\apollo4; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\..\..; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\third_party\tinyusb\source\src; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\hid; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\..\..\..\..\..\devices; ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_hid_on_off.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_hid_on_off.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; apollo4p_blue_kxr_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; CFG_TUSB_DEBUG=0; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; AM_PART_APOLLO4P
  group (top)
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc_hid_on_off.c usb_descriptors_cdc_hid.c usb_disconnect.c
    ../../../../../../third_party/tinyusb/source/src/class/hid/: hid_device.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ../../../../../../devices/: am_devices_button.c am_devices_led.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ./: startup_iar.c
