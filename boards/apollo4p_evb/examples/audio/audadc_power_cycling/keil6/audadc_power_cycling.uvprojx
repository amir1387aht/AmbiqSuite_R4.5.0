# Keil uVision project audadc_power_cycling.uvprojx, settings and files
target audadc_power_cycling (ARM-ADS)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: audadc_power_cycling
  AfterMake: fromelf --bin --output bin\audadc_power_cycling.bin bin\audadc_power_cycling.axf
  AfterMake: fromelf -cedrst --output bin\audadc_power_cycling.txt bin\audadc_power_cycling.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4P AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT keil6
  c include: ../../../../bsp;../src;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../devices;../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../../../../../../mcu/apollo4p
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c audadc_power_cycling.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_syscalls.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4p/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
