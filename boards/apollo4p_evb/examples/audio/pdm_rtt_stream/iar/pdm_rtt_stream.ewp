# IAR project pdm_rtt_stream.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4P; AM_PACKAGE_BGA; SEGGER_RTT_SECTION="SHARED_RW"; AM_UTIL_FAULTISR_PRINT; __FPU_PRESENT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\SEGGER\SEGGER_RTT_V680a\RTT; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4p; ..\src; ..\..\..\..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pdm_rtt_stream.bin
  ILINK.IlinkOutputFile: pdm_rtt_stream.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO4P; AM_PACKAGE_BGA; SEGGER_RTT_SECTION="SHARED_RW"; AM_UTIL_FAULTISR_PRINT; __FPU_PRESENT
  group (top)
    ../src/: am_resources.c pdm_rtt_stream.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ./: startup_iar.c
