# IAR project tinyusb_cdc_msc_freertos_disconnect.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KP-KBR AmbiqMicro AMAP42KP-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; apollo4p_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4P; CFG_TUSB_DEBUG=0; AM_FREERTOS; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\..\..\..\bsp; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\portable\IAR\AMapollo4; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\tinyusb\ambiq_port\apollo4; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\msc; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4p\hal; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\..\..\mcu\apollo4p; ..\..\..\..\..\..\third_party\FreeRTOSv10.5.1\Source\include; ..\src; ..\..\..\..\..\..\third_party\tinyusb\source\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_msc_freertos_disconnect.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_msc_freertos_disconnect.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4p\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; apollo4p_evb; CFG_TUSB_MCU=OPT_MCU_APOLLO4; AM_PART_APOLLO4P; CFG_TUSB_DEBUG=0; AM_FREERTOS; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED
  group (top)
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/IAR/AMapollo4/: port.c portasm.s
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../src/: am_resources.c apollo4_board.c freertos_hook.c msc_disk.c rtos.c tinyusb_cdc_msc_freertos_disconnect.c usb_descriptors.c usb_disconnect.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../devices/: am_devices_button.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ../../../../../../third_party/tinyusb/source/src/class/msc/: msc_device.c
    ./: startup_iar.c
