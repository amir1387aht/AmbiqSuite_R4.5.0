# Keil uVision project pdm_fft.uvprojx, settings and files
target pdm_fft (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: pdm_fft
  AfterMake: fromelf --bin --output bin\pdm_fft.bin bin\pdm_fft.axf
  AfterMake: fromelf -cedrst --output bin\pdm_fft.txt bin\pdm_fft.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: __FPU_PRESENT UNITY_INCLUDE_CONFIG_H AM_PART_APOLLO4B AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT keil6
  c include: ../../../../../../utils;../src;../../../../../../CMSIS/ARM/Include;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4b/hal;../../../../../..;../../../../bsp;../../../../../../devices;../../../../../../mcu/apollo4b
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c pdm_fft.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
