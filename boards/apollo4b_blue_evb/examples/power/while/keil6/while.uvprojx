# Keil uVision project while.uvprojx, settings and files
target while (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: while
  AfterMake: fromelf --bin --output bin\while.bin bin\while.axf
  AfterMake: fromelf -cedrst --output bin\while.txt bin\while.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4B AM_PRINTF_BUFSIZE=256 AM_PACKAGE_BGA keil6
  c include: ../../../../../..;../../../../bsp;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../src;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4b;../../../../../../devices;../../../../../../mcu/apollo4b/hal
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c while.c
  group utils
    ../../../../../../utils/: am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
