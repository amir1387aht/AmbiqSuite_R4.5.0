# Keil uVision project pwr_iom_spi.uvprojx, settings and files
target pwr_iom_spi (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: pwr_iom_spi
  AfterMake: fromelf --bin --output bin\pwr_iom_spi.bin bin\pwr_iom_spi.axf
  AfterMake: fromelf -cedrst --output bin\pwr_iom_spi.txt bin\pwr_iom_spi.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA apollo4b_blue_evb AM_PART_APOLLO4B keil6
  c include: ../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../utils;../../../../../..;../src;../../../../../../devices;../../../../../../mcu/apollo4b;../../../../bsp;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c pwr_control_utils.c pwr_gpio_utils.c pwr_iom_spi.c pwr_iom_utils.c pwr_timer_utils.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
