# Keil uVision project hp_mode_192mhz.uvprojx, settings and files
target hp_mode_192mhz (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: hp_mode_192mhz
  AfterMake: fromelf --bin --output bin\hp_mode_192mhz.bin bin\hp_mode_192mhz.axf
  AfterMake: fromelf -cedrst --output bin\hp_mode_192mhz.txt bin\hp_mode_192mhz.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4B keil6
  c include: ../../../../../../mcu/apollo4b;../../../../../../devices;../../../../bsp;../../../../../../utils;../../../../../../CMSIS/ARM/Include;../src;../../../../../..;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c hp_mode_192mhz.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
