# Keil uVision project hello_world_uart.uvprojx, settings and files
target hello_world_uart (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: hello_world_uart
  AfterMake: fromelf --bin --output bin\hello_world_uart.bin bin\hello_world_uart.axf
  AfterMake: fromelf -cedrst --output bin\hello_world_uart.txt bin\hello_world_uart.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO4B AM_PACKAGE_BGA keil6
  c include: ../../../../bsp;../../../../../../utils;../../../../../..;../src;../../../../../../mcu/apollo4b/hal;../../../../../../mcu/apollo4b;../../../../../../devices;../../../../../../CMSIS/ARM/Include;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c hello_world_uart.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c am_util_string.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
