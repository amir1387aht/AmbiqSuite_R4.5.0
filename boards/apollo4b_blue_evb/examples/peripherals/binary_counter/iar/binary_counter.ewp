# IAR project binary_counter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO4B
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: binary_counter.bin
  ILINK.IlinkOutputFile: binary_counter.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO4B
  group (top)
    ../src/: am_resources.c binary_counter.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../../devices/: am_devices_led.c
    ./: startup_iar.c
