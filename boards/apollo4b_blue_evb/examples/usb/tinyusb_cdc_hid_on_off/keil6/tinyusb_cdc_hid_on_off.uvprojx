# Keil uVision project tinyusb_cdc_hid_on_off.uvprojx, settings and files
target tinyusb_cdc_hid_on_off (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc_hid_on_off
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_hid_on_off.bin bin\tinyusb_cdc_hid_on_off.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc_hid_on_off.txt bin\tinyusb_cdc_hid_on_off.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CFG_TUSB_DEBUG=0 BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED CFG_TUSB_MCU=OPT_MCU_APOLLO4 apollo4b_blue_evb AM_PART_APOLLO4B AM_PACKAGE_BGA keil6
  c include: ../src;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/tinyusb/source/src/common;../../../../../../mcu/apollo4b/hal;../../../../../../third_party/tinyusb/source/src/osal;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../utils;../../../../../../third_party/tinyusb/source/src/class/hid;../../../../../../third_party/tinyusb/ambiq_port/apollo4;../../../../../../devices;../../../../bsp;../../../../../..;../../../../../../third_party/tinyusb/source/src;../../../../../../mcu/apollo4b
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc_hid_on_off.c usb_descriptors_cdc_hid.c usb_disconnect.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group tinyusb_hid
    ../../../../../../third_party/tinyusb/source/src/class/hid/: hid_device.c
  group devices
    ../../../../../../devices/: am_devices_button.c am_devices_led.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
