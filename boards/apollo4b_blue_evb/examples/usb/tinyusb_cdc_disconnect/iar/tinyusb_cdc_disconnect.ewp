# IAR project tinyusb_cdc_disconnect.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; CFG_TUSB_DEBUG=0; AM_PART_APOLLO4B; AM_PACKAGE_BGA; apollo4b_blue_evb; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; CFG_TUSB_MCU=OPT_MCU_APOLLO4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\tinyusb\source\src\osal; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\ambiq_port\apollo4; ..\..\..\..\..\..; ..\src; ..\..\..\..\..\..\third_party\tinyusb\source\src\common; ..\..\..\..\..\..\third_party\tinyusb\source\src\class\cdc; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\tinyusb\source\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc_disconnect.bin
  ILINK.IlinkOutputFile: tinyusb_cdc_disconnect.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; CFG_TUSB_DEBUG=0; AM_PART_APOLLO4B; AM_PACKAGE_BGA; apollo4b_blue_evb; BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED; CFG_TUSB_MCU=OPT_MCU_APOLLO4
  group (top)
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc_disconnect.c usb_descriptors.c usb_disconnect.c
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
    ../../../../../../devices/: am_devices_button.c am_devices_led.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ./: startup_iar.c
