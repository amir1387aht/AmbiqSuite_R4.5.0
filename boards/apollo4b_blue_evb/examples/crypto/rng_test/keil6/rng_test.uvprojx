# Keil uVision project rng_test.uvprojx, settings and files
target rng_test (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: rng_test
  AfterMake: fromelf --bin --output bin\rng_test.bin bin\rng_test.axf
  AfterMake: fromelf -cedrst --output bin\rng_test.txt bin\rng_test.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_UTIL_FAULTISR_PRINT CC_IOT AM_PART_APOLLO4B AM_PACKAGE_BGA keil6
  c include: ../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../third_party/crypto/mbedtls/include;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/crypto/shared/include/pal/no_os;../src;../../../../../../third_party/crypto/host/include;../../../../../../devices;../../../../../../third_party/crypto/shared/include/pal;../../../../../../mcu/apollo4b;../../../../bsp;../../../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c rng_test.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_syscalls.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../third_party/crypto/mbedtls/library/: cryptombedtls.lib
    ../../../../../../third_party/crypto/host/lib/: libcc_312.lib libpal_no_os.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
