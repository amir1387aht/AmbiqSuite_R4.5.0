# IAR project rng_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; CC_IOT; AM_PACKAGE_BGA; AM_PART_APOLLO4B
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\third_party\crypto\shared\include\pal; ..\..\..\..\bsp; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\crypto\mbedtls\include; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\crypto\host\include; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\crypto\shared\include\pal\no_os
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rng_test.bin
  ILINK.IlinkOutputFile: rng_test.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libcc_312.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedcrypto.a; ..\..\..\..\..\..\third_party\crypto\host\lib\libpal_no_os.a; ..\..\..\..\..\..\third_party\crypto\mbedtls\library\libmbedtls.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; CC_IOT; AM_PACKAGE_BGA; AM_PART_APOLLO4B
  group (top)
    ../src/: am_resources.c rng_test.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_syscalls.c
    ./: startup_iar.c
