# Keil uVision project tinyusb_cdc_dual_ports.uvprojx, settings and files
target tinyusb_cdc_dual_ports (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: tinyusb_cdc_dual_ports
  AfterMake: fromelf --bin --output bin\tinyusb_cdc_dual_ports.bin bin\tinyusb_cdc_dual_ports.axf
  AfterMake: fromelf -cedrst --output bin\tinyusb_cdc_dual_ports.txt bin\tinyusb_cdc_dual_ports.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CFG_TUSB_DEBUG=0 AM_PART_APOLLO4B CFG_TUSB_MCU=OPT_MCU_APOLLO4 BOARD_DEVICE_RHPORT_SPEED=OPT_MODE_FULL_SPEED AM_PACKAGE_BGA apollo4b_evb keil6
  c include: ../../../../../../utils;../../../../../..;../../../../../../devices;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/tinyusb/ambiq_port/apollo4;../../../../../../third_party/tinyusb/source/src/common;../../../../../../third_party/tinyusb/source/src/class/cdc;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/tinyusb/source/src/osal;../../../../bsp;../src;../../../../../../mcu/apollo4b;../../../../../../mcu/apollo4b/hal;../../../../../../third_party/tinyusb/source/src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group tinyusb_device
    ../../../../../../third_party/tinyusb/source/src/device/: usbd.c usbd_control.c
  group tinyusb_apollo4
    ../../../../../../third_party/tinyusb/ambiq_port/apollo4/: dcd_apollo4.c
  group tinyusb_common
    ../../../../../../third_party/tinyusb/source/src/common/: tusb_fifo.c
  group src
    ../src/: am_resources.c apollo4_board.c tinyusb_cdc_dual_ports.c usb_descriptors.c
  group tinyusb_src
    ../../../../../../third_party/tinyusb/source/src/: tusb.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
  group tinyusb_cdc
    ../../../../../../third_party/tinyusb/source/src/class/cdc/: cdc_device.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
