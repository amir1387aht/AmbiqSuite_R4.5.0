# Keil uVision project pdm_rtt_stream.uvprojx, settings and files
target pdm_rtt_stream (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: pdm_rtt_stream
  AfterMake: fromelf --bin --output bin\pdm_rtt_stream.bin bin\pdm_rtt_stream.axf
  AfterMake: fromelf -cedrst --output bin\pdm_rtt_stream.txt bin\pdm_rtt_stream.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: __FPU_PRESENT AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO4B SEGGER_RTT_SECTION=\"SHARED_RW\" AM_PACKAGE_BGA keil6
  c include: ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT;../../../../../../utils;../../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../../devices;../../../../../../mcu/apollo4b/hal;../../../../bsp;../../../../../../mcu/apollo4b;../../../../../..;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c pdm_rtt_stream.c
  group SEGGER_RTT
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil6/bin/: libam_hal.lib
