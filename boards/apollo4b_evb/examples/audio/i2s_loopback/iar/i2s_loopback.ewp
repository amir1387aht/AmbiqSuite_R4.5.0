# IAR project i2s_loopback.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4B; AM_UTIL_FAULTISR_PRINT; UNITY_INCLUDE_CONFIG_H; AM_PACKAGE_BGA; __FPU_PRESENT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices; ..\src; ..\..\..\..\..\..; ..\..\..\..\bsp; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2s_loopback.bin
  ILINK.IlinkOutputFile: i2s_loopback.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO4B; AM_UTIL_FAULTISR_PRINT; UNITY_INCLUDE_CONFIG_H; AM_PACKAGE_BGA; __FPU_PRESENT
  group (top)
    ../src/: am_resources.c i2s_loopback.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
